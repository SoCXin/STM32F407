# IAR project RTOSDemo.ewp, settings and files
configuration STM32F4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\user; ..\user\board\; ..\user\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\user\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Source\include; ..\Source\portable\IAR\ARM_CM4F; ..\Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\user\config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../user/: FreeRTOSConfig.h main.c ParTest.c RegTest.s stm32f4xx_it.c
  group Common Demo Source
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c flash.c GenQTest.c integer.c PollQ.c recmutex.c semtest.c sp_flop.c
  group FreeRTOS_Source
    ../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    ../Source/portable/MemMang/: heap_2.c
    ../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ST_and_IAR_code/board
    ../user/board/: iar_stm32f407zg_sk.c
  group ST_and_IAR_code/startup
    ../user/startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group ST_and_IAR_code/STM32F4xx_StdPeriph_Driver
    ../user/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
